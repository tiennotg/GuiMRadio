options:
  parameters:
    generate_options: qt_gui
    id: essai_otp
    output_language: python
    title: Essais de codes tournants
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: GuiMRadio_RadioDecoder_0
  id: GuiMRadio_RadioDecoder
  parameters:
    baud_rate: '2000'
    encoding_type: MANCHESTER
    input_offset: '-0.5'
    sample_rate: samp_rate/16
  states: {}
- name: GuiMRadio_SerialOTPSink_0
  id: GuiMRadio_SerialOTPSink
  parameters:
    otp_basetime: '10'
    otp_secret: motdepasse
    otp_startat: '0'
    otp_type: H_OTP
    serial_baud: '115200'
    serial_bits: '8'
    serial_data: o
    serial_parity: PARITY_NONE
    serial_port: /dev/ttyUSB0
    serial_stopbits: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '16'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/16
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [GuiMRadio_RadioDecoder_0, '0', GuiMRadio_SerialOTPSink_0, '0']
- [blocks_complex_to_mag_0, '0', GuiMRadio_RadioDecoder_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
